SUMMARY = "A library for the MQTT protocol"
SRC_URI = "npm://registry.npmjs.org;name=mqtt;version=${PV}"

S = "${WORKDIR}/npmpkg"

LICENSE = "ISC & BSD-2-Clause & MIT"
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=a76320d876562ab514061e70044b74b7 \
                    file://node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/help-me/LICENSE;md5=6c5e18034ed4abefcb9ac97254596680 \
                    file://node_modules/help-me/node_modules/pump/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/help-me/node_modules/pump/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/help-me/node_modules/pump/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt-connection/LICENSE.md;md5=501ed3e73807d871c7c35db8dfcca424 \
                    file://node_modules/mqtt-connection/node_modules/reduplexer/LICENSE;md5=da3df6fe96c2c2af06d32a62ad7aefa6 \
                    file://node_modules/concat-stream/LICENSE;md5=3ad90c134f824ddfcea611ee1fa567a8 \
                    file://node_modules/concat-stream/node_modules/typedarray/LICENSE;md5=6085b70b74c7dcf7df4e955725e3153d \
                    file://node_modules/concat-stream/node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/concat-stream/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/concat-stream/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/concat-stream/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/concat-stream/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/end-of-stream/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/mqtt-packet/LICENSE.md;md5=e1fb063b09c4d884d11fbc4c93d5c174 \
                    file://node_modules/mqtt-packet/node_modules/bl/LICENSE.md;md5=7489efd5cf7c4575f9898b7eab7aeeb0 \
                    file://node_modules/xtend/LICENCE;md5=96bcdf84e670aafacac9e094bce29ac9 \
                    file://node_modules/reinterval/LICENSE;md5=c65ef22a386436c433298ca42418c200 \
                    file://node_modules/websocket-stream/LICENSE;md5=17c1dd792579df06dfb25f64c81968ec \
                    file://node_modules/websocket-stream/node_modules/duplexify/LICENSE;md5=9befe7026bf915886cd566a98117c80e \
                    file://node_modules/websocket-stream/node_modules/duplexify/node_modules/end-of-stream/node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/websocket-stream/node_modules/duplexify/node_modules/end-of-stream/node_modules/once/node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/websocket-stream/node_modules/duplexify/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/websocket-stream/node_modules/through2/LICENSE;md5=f3827423e10328147d44783718699586 \
                    file://node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/websocket-stream/node_modules/through2/node_modules/readable-stream/node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/websocket-stream/node_modules/ws/node_modules/ultron/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/commist/LICENSE;md5=3f047b8c72633e56a5d2bddc7feaa719 \
                    file://node_modules/commist/node_modules/leven/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/readable-stream/LICENSE;md5=d7351a4fc8e956f1a68413490d5e655e \
                    file://node_modules/readable-stream/node_modules/string_decoder/LICENSE;md5=fcf5cfdc777e49f11402422c72a86f43 \
                    file://node_modules/readable-stream/node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff"

NPM_SHRINKWRAP := "${THISDIR}/${PN}/npm-shrinkwrap.json"
NPM_LOCKDOWN := "${THISDIR}/${PN}/lockdown.json"

inherit npm

LICENSE_${PN}-commist-leven = "MIT"
LICENSE_${PN}-commist = "MIT"
LICENSE_${PN}-concat-stream-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-concat-stream-readable-stream-isarray = "MIT"
LICENSE_${PN}-concat-stream-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-concat-stream-readable-stream-string_decoder = "MIT"
LICENSE_${PN}-concat-stream-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-concat-stream-readable-stream = "MIT"
LICENSE_${PN}-concat-stream-typedarray = "MIT"
LICENSE_${PN}-concat-stream = "MIT"
LICENSE_${PN}-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-end-of-stream-once = "ISC"
LICENSE_${PN}-end-of-stream = "MIT"
LICENSE_${PN}-help-me-pump-once-wrappy = "ISC"
LICENSE_${PN}-help-me-pump-once = "ISC"
LICENSE_${PN}-help-me-pump = "MIT"
LICENSE_${PN}-help-me = "MIT"
LICENSE_${PN}-inherits = "ISC"
LICENSE_${PN}-minimist = "MIT"
LICENSE_${PN}-mqtt-connection-reduplexer = "ISC"
LICENSE_${PN}-mqtt-connection = ""
LICENSE_${PN}-mqtt-packet-bl = "MIT"
LICENSE_${PN}-mqtt-packet = "MIT"
LICENSE_${PN}-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-readable-stream-isarray = "MIT"
LICENSE_${PN}-readable-stream-string_decoder = "MIT"
LICENSE_${PN}-readable-stream = "MIT"
LICENSE_${PN}-reinterval = "MIT"
LICENSE_${PN}-websocket-stream-duplexify-end-of-stream-once-wrappy = "ISC"
LICENSE_${PN}-websocket-stream-duplexify-end-of-stream-once = "ISC"
LICENSE_${PN}-websocket-stream-duplexify-end-of-stream = "MIT"
LICENSE_${PN}-websocket-stream-duplexify-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-websocket-stream-duplexify-readable-stream-isarray = "MIT"
LICENSE_${PN}-websocket-stream-duplexify-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-websocket-stream-duplexify-readable-stream-string_decoder = "MIT"
LICENSE_${PN}-websocket-stream-duplexify-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-websocket-stream-duplexify-readable-stream = "MIT"
LICENSE_${PN}-websocket-stream-duplexify = "MIT"
LICENSE_${PN}-websocket-stream-through2-readable-stream-core-util-is = "MIT"
LICENSE_${PN}-websocket-stream-through2-readable-stream-isarray = "MIT"
LICENSE_${PN}-websocket-stream-through2-readable-stream-process-nextick-args = "MIT"
LICENSE_${PN}-websocket-stream-through2-readable-stream-string_decoder = "MIT"
LICENSE_${PN}-websocket-stream-through2-readable-stream-util-deprecate = "MIT"
LICENSE_${PN}-websocket-stream-through2-readable-stream = "MIT"
LICENSE_${PN}-websocket-stream-through2 = "MIT"
LICENSE_${PN}-websocket-stream-ws-options = "MIT"
LICENSE_${PN}-websocket-stream-ws-ultron = "MIT"
LICENSE_${PN}-websocket-stream-ws = "MIT"
LICENSE_${PN}-websocket-stream = "BSD-2-Clause"
LICENSE_${PN}-xtend = "MIT"
LICENSE_${PN} = "MIT"
